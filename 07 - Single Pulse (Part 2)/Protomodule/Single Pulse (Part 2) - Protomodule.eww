<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Single Pulse (Part 2) - Protomodule.ewp</path>
  </project>
  <batchBuild/>
</workspace>


