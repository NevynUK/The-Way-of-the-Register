<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Timer 1 Counting Modes - Protomodule.ewp</path>
  </project>
  <batchBuild/>
</workspace>


