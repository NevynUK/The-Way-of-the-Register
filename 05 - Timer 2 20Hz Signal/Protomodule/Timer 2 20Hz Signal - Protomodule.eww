<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Timer 2 20Hz Signal - Protomodule.ewp</path>
  </project>
  <batchBuild/>
</workspace>


