<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Basic GO 1.0 Module STM8S103.ewp</path>
  </project>
  <batchBuild/>
</workspace>


