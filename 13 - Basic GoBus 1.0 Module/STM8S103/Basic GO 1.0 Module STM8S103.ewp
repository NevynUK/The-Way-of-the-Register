# IAR project Basic GO 1.0 Module STM8S103.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; DEBUG
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Basic GO 1.0 Module STM8S103.hex
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../: main.c
