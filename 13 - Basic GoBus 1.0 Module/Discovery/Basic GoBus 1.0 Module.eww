<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Basic GoBus 1.0 Module.ewp</path>
  </project>
  <batchBuild/>
</workspace>


