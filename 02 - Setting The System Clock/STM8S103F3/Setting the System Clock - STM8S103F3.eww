<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Setting the System Clock - STM8S103F3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


