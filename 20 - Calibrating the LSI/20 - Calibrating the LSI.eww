<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\20 - Calibrating the LSI.ewp</path>
  </project>
  <batchBuild/>
</workspace>


